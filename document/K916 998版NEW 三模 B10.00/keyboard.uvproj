# Keil uVision project keyboard.uvproj, settings and files
target Target 1 (MCS-51)
  device: SH68F90 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0xFFFF) XRAM(0-0x1000) CLOCK(24000000)
  output: keyboard +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 ISP_SH68F90_1107.INC
    ./src/: interrupt.c main.c sys_init.c usb_task.c KeyCode.c led_con.c Display.c Display_PaoMa1.c Display_PWM_Mode.c std_scan.c Mode_Change.c Display_PaoMa2.c KeyDown_Led.c Display_Raindrops.c Display_BoLang.c flash_driver.c Effect_light_1.c Effect_light_2.c PaoHeng.c Display_WASD.c isp.c Display_PaoMa3.c Display_LiuGuang.c Macro.C SPI_Data.c Logo.c wheel.c Text_EMI.c Color.c Manual_Macro.c fill_rom.asm
