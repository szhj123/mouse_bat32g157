# Keil uVision project usbd.uvprojx, settings and files
target BAT32G157 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BAT32G157GK48FA Cmsemicon
  pack: Cmsemicon.BAT32G157.1.00.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: usbd
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Source\usb_driver\inc;..\Source\src\driver\inc;..\Source\src\hw\inc;..\Source\src\byteq;..\Source\src\inc;..\..\..\Driver\inc;..\Source\src\apl_config;..\Source\src\apl_config\pmsc\ram_disk;..\Source\src;..\app\inc;..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000100 size 0x7f00
  group Source
    ../Source/: main.c usb_puac_apl.c usb_puac_descriptor.c
    ../app/src/: ssie_api.c wm8978.c
  group Drivers
    ../../../Driver/src/: clk.c dma.c sci.c pcbz.c retarget.c
    ../driver/src/: ssie_user.c
  group usb_puac
    ../Source/src/apl_config/puac/: usb_puac_driver.c
  group USBDriver
    ../Source/src/driver/: usb_cdataio.c usb_clibusbip.c usb_hbc.c usb_hdriver.c usb_hdriverapi.c usb_hlibusbip.c usb_hscheduler.c usb_hsignal.c usb_hstdfunction.c usb_pbc.c usb_pcontrolrw.c usb_pdriver.c usb_pintfifo.c usb_pinthandler_usbip0.c usb_plibusbip.c usb_psignal.c usb_pstdfunction.c usb_pstdrequest.c usb_usbif_api.c
  group USBhw
    ../Source/src/hw/: usb_157_mcu.c usb_creg_abs.c usb_creg_access.c usb_dma.c usb_hreg_abs.c usb_hreg_access.c usb_preg_abs.c usb_preg_access.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
