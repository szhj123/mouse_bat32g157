# IAR project BAT32G15x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: BAT32G157 CMS BAT32G157
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\Include; ..\..\..\Driver\inc; ..\Source\src\driver\inc; ..\Source\src\hw\inc; ..\Source\src\inc; ..\Source\src\byteq; ..\Source\src\apl_config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BAT32G15x.bin
  ILINK.IlinkOutputFile: BAT32G15x.out
  ILINK.IlinkIcfFile: BAT32G157.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../Device/Source/IAR/: startup_BAT32G157.s
    ../../../Device/Source/: system_BAT32G157.c
  group Driver
    ../../../Driver/src/: clk.c
  group usb_phid
    ../Source/src/apl_config/phid/: usb_phid_driver.c
  group USBDriver
    ../Source/src/driver/: usb_cdataio.c usb_clibusbip.c usb_hbc.c usb_hdriver.c usb_hdriverapi.c usb_hlibusbip.c usb_hscheduler.c usb_hsignal.c usb_hstdfunction.c usb_pbc.c usb_pcontrolrw.c usb_pdriver.c usb_pintfifo.c usb_pinthandler_usbip0.c usb_plibusbip.c usb_psignal.c usb_pstdfunction.c usb_pstdrequest.c usb_usbif_api.c
  group USBhw
    ../Source/src/hw/: usb_157_mcu.c usb_creg_abs.c usb_creg_access.c usb_dma.c usb_hreg_abs.c usb_hreg_access.c usb_preg_abs.c usb_preg_access.c
  group User
    ../Source/: main.c usb_phid_descriptor.c usb_phid_echo_apl.c usb_phid_keyboard_apl.c
