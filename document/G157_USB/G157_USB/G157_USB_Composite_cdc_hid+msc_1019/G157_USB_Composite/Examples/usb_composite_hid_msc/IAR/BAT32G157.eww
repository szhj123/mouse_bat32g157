<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BAT32G15x.ewp</path>
    </project>
    <batchBuild />
</workspace>
