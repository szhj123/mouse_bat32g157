# Keil uVision project LPC11U14GM.uvproj, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC11U34/311 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x9FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: PixArtGamingMice +hex
  AfterMake: run.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __DEBUG_FLASH
  c include: .\Inc
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x5000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x5000 size 0x100
  group Source Group
    ./Src/: core_cm0.c gpio.c hiduser.c system_LPC11Uxx.c timer16.c timer32.c uart.c usbcore.c usbdesc.c usbhw.c usbuser.c startup_LPC11Uxx.s main.c ssp.c Systick.c Keytbl.c I2c.c Pixart_Sensor.c Flash.c srom.c
    ./Inc/: Pixart_Sensor.h
