# Keil uVision project application.uvprojx, settings and files
target application (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: BAT32G157GK48FA Cmsemicon
  pack: Cmsemicon.BAT32G157.1.00.4
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: usbd
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Usb_Lib\usb_driver\inc;..\Usb_Lib\src\driver\inc;..\Usb_Lib\src\hw\inc;..\Usb_Lib\src\byteq;..\Usb_Lib\src\inc;..\Driver\inc;..\Usb_Lib\src\apl_config;..\Usb_Lib\src\apl_config\pmsc\ram_disk;..\Usb_Lib\src\apl_config\hmsc\inc;..\Usb_Lib\src\apl_config\pmsc\ext_flash_disk;..\CMSIS\Include;..\User\App;..\User\Drv;..\User\Hal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ../Device/Source/ARM/: startup_BAT32G157.s
  group Cmsis
    ../Device/Source/: system_BAT32G157.c
  group Drivers
    ../Driver/src/: cmp.c sci.c clk.c gpio.c dma.c
  group USBDriver
    ../Usb_Lib/src/driver/: usb_cdataio.c usb_clibusbip.c usb_hbc.c usb_hdriver.c usb_hdriverapi.c usb_hlibusbip.c usb_hscheduler.c usb_hsignal.c usb_hstdfunction.c usb_pbc.c usb_pcontrolrw.c usb_pdriver.c usb_pintfifo.c usb_pinthandler_usbip0.c usb_plibusbip.c usb_psignal.c usb_pstdfunction.c usb_pstdrequest.c usb_usbif_api.c
  group USBhw
    ../Usb_Lib/src/hw/: usb_157_mcu.c usb_creg_abs.c usb_creg_access.c usb_dma.c usb_hreg_abs.c usb_hreg_access.c usb_preg_abs.c usb_preg_access.c
  group usb_pmsc
    ../Usb_Lib/src/apl_config/pmsc/: media_driver_api.c usb_atapi_driver.c usb_pmsc_driver.c
  group usb_phid
    ../Usb_Lib/src/apl_config/phid/: usb_phid_driver.c
  group App
    ../User/App/: main.c usb_phid_pmsc_apl.c usb_phid_pmsc_descriptor.c app_event.c app_key.c app_lcd.c app_rgb.c
  group Drv
    ../User/Drv/: drv_task.c drv_timer.c drv_event.c drv_key.c drv_lcd.c drv_mouse_sensor.c drv_rgb.c drv_spi_flash.c
  group Hal
    ../User/Hal/: hal_task.c hal_timer.c interrupt.c hal_key.c hal_lcd.c hal_mouse_sensor.c hal_rgb.c hal_spi_flash.c
